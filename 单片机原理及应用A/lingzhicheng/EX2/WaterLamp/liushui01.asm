		ORG		0000H
		AJMP	START
		ORG 	0100H
START:
		CLR 	P1.0
		ACALL	DELAY
		SETB 	P1.0
		CLR 	P1.1
		ACALL	DELAY
		SETB 	P1.1
		CLR 	P1.2
		ACALL	DELAY
		SETB 	P1.2
		CLR 	P1.3
		ACALL	DELAY
		SETB 	P1.3
		CLR 	P1.4
		ACALL	DELAY
		SETB 	P1.4
		CLR 	P1.5
		ACALL	DELAY
		SETB 	P1.5
		CLR 	P1.6
		ACALL	DELAY
		SETB 	P1.6
		CLR 	P1.7
		ACALL	DELAY
		SETB 	P1.7
		ACALL	DELAY
		AJMP	START
DELAY:	MOV		R5,#20
D2:		MOV		R6,#20
D1:		MOV		R7,#248
D3:		DJNZ	R7,D3
		DJNZ	R6,D1
		DJNZ	R5,D2
		RET
		
		END
	