		ORG		0000H
		AJMP	START
		ORG 	0100H
START:	
		MOV		DPTR,#TAB
		MOV		R0,#00H		;COUNT
S1:		MOV		P2,#0FFH	;初始
S2:		MOV		A,R0
		MOVC	A,@A+DPTR
		MOV		P2,A
		LCALL	DELAY
		INC		R0;
		CJNE	R0,#10,S2
		MOV		R0,#00H
		LJMP	S1
		
DELAY:	MOV		R5,#100
D2:		MOV		R6,#20
D1:		MOV		R7,#248
D3:		DJNZ	R7,D3
		DJNZ	R6,D1
		DJNZ	R5,D2
		RET
		
TAB:	DB		0F9H,0A4H,0B0H,99H,92H,82H,0F8H,80H,90H
		DB		0FFH
		END