# Keil uVision project TIMER0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: TIMER0 +hex
  c flags: Optimize=2 SizeSpeed=1
  group Source Group 1
    ./: timer0.asm
